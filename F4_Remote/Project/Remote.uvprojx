# Keil uVision project Remote.uvprojx, settings and files
target Target_1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Remote
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F411xE
  c include: ..\Libraries\CMSIS;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Libraries\STM32F4xx_StdPeriph_Driver;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\Driver;..\System;..\BSP;..\APP;..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group CMSIS
    ../Libraries/CMSIS/: startup_stm32f411xe.s system_stm32f4xx.c
  group StdPeriph_Driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group System
    ../System/: system.h systick.c systick.h
  group FreeRTOS_Core
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_Port
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group Driver
    ../Driver/: adc.c adc.h spi.c spi.h pwm.c pwm.h i2c.c i2c.h usart.c usart.h dma.c dma.h
  group BSP
    ../BSP/: led.c led.h nrf24l01.c nrf24l01.h lcd.c lcd.h image.h ctp.c ctp.h fonts.h key.c key.h
  group APP
    ../APP/: rc.c rc.h screen.c screen.h remote.c remote.h touch.c touch.h
  group User
    ../User/: main.c
    ../Libraries/STM32F4xx_StdPeriph_Driver/: stm32f4xx_it.c stm32f4xx_conf.h
    ../FreeRTOS/include/: FreeRTOSConfig.h
